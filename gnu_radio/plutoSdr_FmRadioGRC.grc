options:
  parameters:
    generate_options: qt_gui
    id: plutoSdr_FmRadioGRC
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2800000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '8'
    quad_rate: '384000'
  states: {}
- name: audio_device
  id: parameter
  parameters:
    label: Audio device
    type: str
    value: default
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: default
    samp_rate: '48000'
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: Decimation
    type: intx
    value: '1'
  states: {}
- name: fm_station
  id: parameter
  parameters:
    label: FM Station
    type: eng_float
    value: '89800000'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '131072'
    filter_source: '''Auto'''
    frequency: fm_station
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:pluto.local
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '44100'
    decim: '7'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '44100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: fm_station
    fftsize: '1024'
    name: '"Receive Signal"'
    type: complex
  states: {}
- name: uri
  id: parameter
  parameters:
    label: URI
    type: str
    value: ip:pluto.local
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
